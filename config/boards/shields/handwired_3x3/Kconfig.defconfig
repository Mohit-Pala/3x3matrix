## config/boards/shields/handwired_3x3/Kconfig.defconfig
```kconfig
if SHIELD_HANDWIRED_3X3

config ZMK_KEYBOARD_NAME
    default "3x3 Matrix"

config ZMK_SLEEP
    default y

endif
```
